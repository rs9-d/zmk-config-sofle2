## boards/shields/sofle2/Kconfig.shield.txt
```kconfig
# No whitespace after the comma or in the keyboard name!
config SHIELD_SOFLE2_DONGLE
    def_bool $(shields_list_contains,sofle2_dongle)
```
